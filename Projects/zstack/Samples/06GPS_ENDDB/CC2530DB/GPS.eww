<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\GPS.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>GPS</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>GPS</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>GPS</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


